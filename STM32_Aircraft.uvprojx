# Keil uVision project STM32_Aircraft.uvprojx, settings and files
target Target1 (ARM-ADS)
  device: STM32F407VG STMicroelectronics
  pack: Keil.STM32F4xx_DFP.2.4.0
  cpu: IROM(0x08000000,0x100000) IRAM(0x20000000,0x20000) IRAM2(0x10000000,0x10000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: IO_Toggle
  c flags: Optim=4 OneElfS=1
  c define: USE_STDPERIPH_DRIVER,STM32F4XX,__FPU_PRESENT=1,__FPU_USED =1
  c include: .\;..\STM32F4-Discovery_FW_V1.1.0\Libraries\CMSIS\Include;..\STM32F4-Discovery_FW_V1.1.0\Libraries\CMSIS\ST\STM32F4xx\Include;..\STM32F4-Discovery_FW_V1.1.0\Libraries\STM32F4xx_StdPeriph_Driver\inc;..\STM32F4-Discovery_FW_V1.1.0\Utilities\STM32F4-Discovery;.\Utilities;.\Drivers;.\Misc;.\Aircraft;.\Modules;.\User
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x100000
  memory RVCT9: RAM 0x20000000 size 0x20000
  memory RVCT10: RAM 0x10000000 size 0x10000
  group Root
    ./: Aircraft.cpp stm32f4xx_it.cpp
  group STM32F4-Discovery
    ../STM32F4-Discovery_FW_V1.1.0/Utilities/STM32F4-Discovery/: stm32f4_discovery.c
  group STM32F4xx_StdPeriph_Driver
    ../STM32F4-Discovery_FW_V1.1.0/Libraries/STM32F4xx_StdPeriph_Driver/src/: stm32f4xx_rcc.c misc.c stm32f4xx_gpio.c stm32f4xx_exti.c stm32f4xx_syscfg.c stm32f4xx_fsmc.c stm32f4xx_usart.c stm32f4xx_tim.c
  group MDK-ARM
    ../STM32F4-Discovery_FW_V1.1.0/Libraries/CMSIS/ST/STM32F4xx/Source/Templates/arm/: startup_stm32f4xx.s
  group CMSIS
    ./: system_stm32f4xx.cpp
  group Drivers
    ./Drivers/: Pin.cpp Timer.cpp PWM.cpp IIC.c
  group Utilities
    ./Utilities/: Motor.cpp LCD.cpp AsciiLib.cpp
  group Misc
    ./Misc/: Formatter.cpp myDelay.cpp
  group Aircraft
    ./Aircraft/: Receiver.cpp Stick.cpp Controller.cpp PID.cpp
  group Modules
    ./Modules/: delay.c usart.c
  group User
    ./User/: util.c
